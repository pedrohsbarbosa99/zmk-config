## boards/shields/stream_cheap/Kconfig.defconfig
```kconfig
if SHIELD_STREAM_CHEAP

config ZMK_KEYBOARD_NAME
    default "stream_cheap"

endif # SHIELD_STREAM_CHEAP
```
